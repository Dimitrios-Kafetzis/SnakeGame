# Keil uVision project Snake_Game.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM3S1968 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: Display_Switch
  c flags: Optim=1
  c include: ..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: Startup.s gpio.c gpio.h registersDimi.h Snake_Game_Main.c
    ../OLED_1968/: Output.c rit128x96x4.c
  group Library
    ../driverlib/rvmdk-cm3/: driverlib-cm3.lib
